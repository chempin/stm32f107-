# Keil uVision project 串口实验.uvproj, settings and files
target USERT (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: 串口实验 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\CORE;..\STM32FWLIB\inc
  asm define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  asm include: ..\USER;..\OV;..\CORE;..\STM32FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_md.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../STM32FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
