# Keil uVision project wifi.uvproj, settings and files
target WIFI (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: wifi +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32FWLIB\inc;..\CORE;..\ATK-ESP8266;..\FATFS\exfuns;..\FATFS\src;..\FATFS\src\option;..\OV\24CXX;..\OV\FLASH;..\OV\KEY;..\OV\LCD;..\OV\LED;..\OV\SD;..\OV\SPI;..\OV\TOUCH;..\OV\USART2;..\OV\IIC;..\MALLOC;..\TEXT;..\USMART
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group OV
    ../OV/24CXX/: 24cxx.c
    ../OV/FLASH/: flash.c
    ../OV/IIC/: myiic.c
    ../OV/KEY/: key.c
    ../OV/LCD/: lcd.c
    ../OV/LED/: led.c
    ../OV/SD/: MMC_SD.C
    ../OV/SPI/: spi.c
    ../OV/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../OV/USART2/: usart2.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group ATKESP8266
    ../ATK-ESP8266/: apsta.c common.c wifiap.c wifista.c
  group MALLOC
    ../MALLOC/: malloc.c
